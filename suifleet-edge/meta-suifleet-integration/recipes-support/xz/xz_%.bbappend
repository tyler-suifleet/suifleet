# Shared with standalone consumers through meta-suifleet's opt-in class; see
# its header for the observed defect and series/variant scoping.
inherit suifleet-core-fixes
